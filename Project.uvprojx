# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\CMSIS;.\Libraries\FatFS;.\USER\usb_mass;.\USER\BSP;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c io_functions.c spi_flash_fatfs.c spi_flash_fatfs_config.c spi_flash_fatfs_mp3.c spi_w5500_eth.c uart_consola.c uart_fifo_gps.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./USER/: stm32f10x_it.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-Mass
    ./USER/usb_mass/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_hw.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB-FS-Device_Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c usb_core.c
  group FatFS
    ./Libraries/FatFS/: diskio.c ff.c
  group BSP
    ./USER/BSP/: bsp_24L01.c bsp_adc.c bsp_i2c.c bsp_io.c bsp_iwdg.c bsp_spi_bus.c bsp_spi_flash.c bsp_uart_fifo.c bsp_vs1053b.c bsp_w5500.c
software components: CMSIS:CORE 5.4.0
